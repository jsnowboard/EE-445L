# Keil uVision project PeriodicTimer0AInts.uvprojx, settings and files
target PeriodicTimer0AInts (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PeriodicTimer0AInts
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Source
    ./: startup.s PeriodicTimer0AInts.c
    ../mymodules/: music.c portf_init.c Timer0A.c PLL.c Timer0B.c notes.c switch.c timer_init.c DAC.c
software components: CMSIS:CORE 4.3.0
